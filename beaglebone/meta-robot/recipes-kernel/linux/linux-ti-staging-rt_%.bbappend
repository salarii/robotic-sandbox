FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI += "file://pru.cfg \
            file://0001-am335x-boneblack-add-pru0-pinmux-on-P9_30.patch"
